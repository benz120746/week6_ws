Commit message: Update rbkairos.urdf

File: rbkairos.urdf (robot description, URDF)
Before this commit: robot rbkairos, 28 links, 27 joints
Joints:
- joint front_laser_base_joint: origin xyz=0.2865 -0.20894 0.2973 rpy=0 -3.141592653589793 2.356194490192345 -> xyz=0.2865 0 0.2973 rpy=0 0 0
